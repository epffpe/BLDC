# IAR project bldc_sensorless.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x40
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: CONF; ..\..\COMMON\LIB_MCU\TWI; ..\..\COMMON\LIB_MCU; ..\..\COMMON\USI_TWI_slave
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny861.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: main.c mc_control.c mc_drv.c
